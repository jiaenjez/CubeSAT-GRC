options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: SDR_TX
    output_language: python
  states: {}

blocks:
- name: samp_per_sym
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*3.14*1000/samp_rate
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*500)
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-1700'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1200'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: samp_per_sym
    type: byte
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {state: disabled}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      File : gr-APRS/WAV/aprs.wav
      sample rate : 24 kHz
      bit depth : 16 bits
    file: /home/desktop/Downloads/satnogs_3627707_2021-02-12T07-06-55.wav
    repeat: 'True'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {state: disabled}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: limesdr_sink_0_0_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    analog_bandw_ch1: 10e6
    calibr_bandw_ch0: '0'
    calibr_bandw_ch1: 10e6
    channel_mode: '0'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '45'
    gain_dB_ch1: '30'
    oversample: '0'
    rf_freq: 435e6
    samp_rate: 1.024e6
    serial: 00090706024F1B11
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tab@0:1,0,1,1
    legend: 'False'
    name: Input Spectrum
    showports: 'True'
    type: complex
    width1: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-150'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@1:0,0,1,1
    label1: ''
    legend: 'False'
    name: Demodulator Output
    size: '512'
    srate: baud*2
    type: float
    width1: '2'
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@1:1,0,1,1
    label1: ''
    legend: 'False'
    name: Clock Sync Output
    size: '256'
    srate: baud
    type: float
    width1: '2'
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@0:0,0,1,1
    label1: ''
    label2: ''
    legend: 'False'
    name: Input Waveform
    size: '1024'
    srate: '48000'
    type: complex
    width1: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: 10e6
    clock_source0: internal
    dc_offset_mode0: '2'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate * 10
    sync: none
    type: fc32
  states: {state: disabled}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {state: disabled}
- name: satellites_hdlc_framer_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '7'
    preamble_bytes: '50'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {state: disabled}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: satellites_satellite_decoder_0_0_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /home/desktop/gr-satellites-3.6.0/python/satyaml/FALCONSAT-3.yml
    norad: ''
    samp_rate: '48000'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Input Signal
    num_tabs: '1'
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_1_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1_0, '1']
- [blocks_char_to_float_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_complex_to_float_0, '0', hilbert_fc_0, '0']
- [blocks_multiply_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_multiply_xx_1_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_xx_1_0, '0', limesdr_sink_0_0_0, '0']
- [blocks_multiply_xx_1_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [blocks_multiply_xx_1_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [blocks_multiply_xx_1_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', satellites_nrzi_encode_0, '0']
- [blocks_repeat_0, '0', blocks_char_to_float_0, '0']
- [blocks_wavfile_source_0_0, '0', satellites_satellite_decoder_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '1']
- [satellites_hdlc_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_hdlc_deframer_0, out, blocks_socket_pdu_0_0, pdus]
- [satellites_hdlc_framer_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [satellites_nrzi_decode_0, '0', satellites_hdlc_deframer_0, '0']
- [satellites_nrzi_encode_0, '0', blocks_repeat_0, '0']
- [satellites_satellite_decoder_0_0_0, out, satellites_hdlc_framer_0, in]

metadata:
  file_format: 1
