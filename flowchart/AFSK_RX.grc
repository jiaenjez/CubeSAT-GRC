options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: SDR_RX
    output_language: python
  states: {}

blocks:
- name: samp_per_sym
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*3.14*1000/samp_rate
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*500)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-1700'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1200'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: samp_per_sym
    type: byte
  states: {state: disabled}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      File : gr-APRS/WAV/aprs.wav
      sample rate : 24 kHz
      bit depth : 16 bits
    file: /home/desktop/Downloads/satnogs_3627707_2021-02-12T07-06-55.wav
    repeat: 'True'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {}
- name: limesdr_sink_0_0_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch1: 10e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 10e6
    channel_mode: '0'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '30'
    gain_dB_ch1: '30'
    oversample: '1'
    rf_freq: 435e6
    samp_rate: 1.44e6
    serial: 00090706024F1B11
  states: {state: disabled}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    ch_align: 'False'
    channel_mode: '0'
    digital_bandw_ch0: '0'
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: 435e6
    samp_rate: 1.024e6
    serial: 0009072C02880B2D
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tab@0:1,0,1,1
    legend: 'False'
    name: Input Spectrum
    showports: 'True'
    type: complex
    width1: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-150'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@1:0,0,1,1
    label1: ''
    legend: 'False'
    name: Demodulator Output
    size: '512'
    srate: baud*2
    type: float
    width1: '2'
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@1:1,0,1,1
    label1: ''
    legend: 'False'
    name: Clock Sync Output
    size: '256'
    srate: baud
    type: float
    width1: '2'
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@0:0,0,1,1
    label1: ''
    label2: ''
    legend: 'False'
    name: Input Waveform
    size: '1024'
    srate: '48000'
    type: complex
    width1: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '30'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '30'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: satellites_hdlc_framer_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '7'
    preamble_bytes: '50'
  states: {state: disabled}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {state: disabled}
- name: satellites_satellite_decoder_0_0_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /home/desktop/gr-satellites-3.6.0/python/satyaml/FALCONSAT-3.yml
    norad: ''
    samp_rate: '48000'
  states: {state: disabled}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Input Signal
    num_tabs: '1'
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_1_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1_0, '1']
- [blocks_char_to_float_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_complex_to_float_0, '0', hilbert_fc_0, '0']
- [blocks_multiply_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_multiply_xx_1_0, '0', rational_resampler_xxx_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', satellites_nrzi_encode_0, '0']
- [blocks_repeat_0, '0', blocks_char_to_float_0, '0']
- [blocks_wavfile_source_0_0, '0', satellites_satellite_decoder_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '1']
- [limesdr_source_0, '0', blocks_complex_to_float_0, '0']
- [limesdr_source_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [limesdr_source_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [limesdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [limesdr_source_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', blocks_complex_to_float_0, '0']
- [satellites_hdlc_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_hdlc_deframer_0, out, blocks_socket_pdu_0_0, pdus]
- [satellites_hdlc_framer_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [satellites_nrzi_decode_0, '0', satellites_hdlc_deframer_0, '0']
- [satellites_nrzi_encode_0, '0', blocks_repeat_0, '0']
- [satellites_satellite_decoder_0_0_0, out, satellites_hdlc_framer_0, in]

metadata:
  file_format: 1
